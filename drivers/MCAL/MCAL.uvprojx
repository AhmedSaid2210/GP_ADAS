# Keil uVision project MCAL.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MCAL (library)
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\ti\TivaWare_C_Series-2.2.0.295
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MCAL
    ./: delay.c delay.h GPIO.c GPIO.h GPIO_Config.c GPIO_Config.h RCC.c RCC.h RCC_Config.c RCC_Config.h Std_Macros.h Std_Types.h SysTick.c SysTick.h Timer.c Timer.h Timer_Config.c Timer_Config.h SPI.c SPI.h SPI_Config.c SPI_Config.h PWM.c PWM.h PWM_Config.c PWM_Config.h pin_map.h
  group lib
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/ccs/Debug/: driverlib.lib
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
