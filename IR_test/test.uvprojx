# Keil uVision project test.uvprojx, settings and files
target app (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\ti\TivaWare_C_Series-2.2.0.295;..\drivers\MCAL;..\drivers\HAL;..\drivers\App
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: app.c
  group lib
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
    ../drivers/MCAL/Objects/: MCAL.lib
  group MCAL_config
    ../drivers/MCAL/: GPIO_Config.c GPIO_Config.h RCC_Config.h RCC_Config.c delay.h SysTick.h Timer_Config.h Timer_Config.c Std_Types.h Std_Macros.h PWM_Config.h PWM_Config.c Timer.h Timer.c RCC.c RCC.h GPIO.h GPIO.c SPI.c SPI.h SPI_Config.c SPI_Config.h PWM.h PWM.c UART_Config.c UART_Config.h UART.h UART.c sleep.h sleep.c SysTick.c Watchdog.h Watchdog.c
  group HAL_config
    ../drivers/HAL/: lcd.h lcd.c ultrasonic.h ultrasonic.c ultrasonic_Config.h ultrasonic_Config.c motor.h motor.c motor_Config.c motor_Config.h IR_Config.h IR_Config.c IR.h IR.c communication.c communication.h
software components: CMSIS:CORE 5.6.0, RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Heap 10.5.1, RTOS:Timers 10.5.1, Device:Startup 1.0.1
